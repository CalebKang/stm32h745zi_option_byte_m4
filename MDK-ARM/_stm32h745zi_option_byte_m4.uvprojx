# Keil uVision project _stm32h745zi_option_byte_m4.uvprojx, settings and files
target _stm32h745zi_option_byte_m4_CM4 (ARM-ADS)
  device: STM32H745ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x10000000-0x10047FFF) IRAM2(0x18000000-0x1800FFFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: _stm32h745zi_option_byte_m4_CM4 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H745xx,USE_FULL_LL_DRIVER
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x18000000 size 0x10000
  scatter file: stm32h745xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h745xx_CM4.s startup_stm32h745xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c flash_if.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
target _stm32h745zi_option_byte_m4_CM7 (ARM-ADS)
  device: STM32H745ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: _stm32h745zi_option_byte_m4_CM7
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H745xx,USE_FULL_LL_DRIVER
  c include: ../CM7/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h745xx_flash_CM7.sct
software components: CMSIS:CORE 4.3.0
